require python-empy.inc

#inherit distutils3
# Wrynose-compatible
inherit setuptools3
